# Keil uVision project test.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\USER;..\FWLib\inc;..\CMSIS;..\MY\inc;..\MY\code;..\MY\lcd;..\MY\delay;..\MY\sys;..\MY\TIMER;..\MY\adc;..\MY\OLED;..\MY\usart;..\MY\SPI;..\MY\display;..\FreeRTOS;..\FreeRTOS\portable;..\FreeRTOS\include;..\MY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c
    ../MY/sys/: sys.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group MY
    ../MY/LED/: led.c
    ../MY/lcd/: lcd.c
    ../MY/delay/: delay.c
    ../MY/TIMER/: timer.c
    ../MY/adc/: adc.c
    ../MY/usart/: usart.c
    ../MY/SPI/: spi.c
    ../MY/display/: display.c
    ../MY/: My_InitTask.c vios.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/: heap_2.c port.c
